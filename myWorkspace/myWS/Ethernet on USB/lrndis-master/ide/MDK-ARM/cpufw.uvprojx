# Keil uVision project cpufw.uvprojx, settings and files
target cpufw (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cpufw +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\..\project;..\..\cmsis;..\..\std-periph;..\..\std-periph\inc;..\..\usb-core\dev-driver;..\..\usb-core\otg-driver;..\..\usb-files;..\..\usb-files\rndis;..\..\lrndis\lwip-1.4.1\src\include;..\..\lrndis\lwip-1.4.1\src\include\ipv4;..\..\lrndis\rndis-stm32;..\..\lrndis\dhcp-server;..\..\lrndis\dns-server;..\..\lrndis\lwip-1.4.1\apps\httpserver_raw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group project
    ../../project/: app.c Interrupts.c Interrupts.h stm32f4xx_conf.h system_stm32f4xx.c startup_stm32f4xx.s time.c time.h stm32f4_discovery.c stm32f4_discovery.h stm32f4_discovery_lis302dl.c stm32f4_discovery_lis302dl.h
  group usb-files
    ../../usb-files/: usb_bsp.c usbd_usr.c
  group usb-dev-core
    ../../usb-core/dev-driver/: usbd_req.h usbd_req.c usbd_ioreq.h usbd_def.h usbd_ioreq.c usbd_core.h usbd_core.c
  group usb-otg-core
    ../../usb-core/otg-driver/: usb_bsp.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_defines.h usb_regs.h
  group std-periph
    ../../std-periph/src/: stm32f4xx_pwr.c stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_spi.c
  group lrndis-lwip
    ../../lrndis/lwip-1.4.1/src/include/: lwipopts.h
    ../../lrndis/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../lrndis/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../lrndis/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group lrndis-stm32
    ../../lrndis/rndis-stm32/: usbd_rndis_core.h usbd_rndis_core.c rndis_protocol.h ndis.h usb_conf.h usbd_conf.h usbd_desc.c usbd_desc.h
  group lrndis-dhcp
    ../../lrndis/dhcp-server/: dhserver.c dhserver.h
  group lrndis-dns
    ../../lrndis/dns-server/: dnserver.c dnserver.h
  group lrndis-http
    ../../lrndis/lwip-1.4.1/apps/httpserver_raw/: fs.c httpd.c
software components: CMSIS:CORE 5.5.0
